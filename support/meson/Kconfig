## support/meson/Kconfig
```kconfig
mainmenu "sample Kconfig"

config SAMPLE_FLAG
	bool "sample configuration flag"
	default y
```
